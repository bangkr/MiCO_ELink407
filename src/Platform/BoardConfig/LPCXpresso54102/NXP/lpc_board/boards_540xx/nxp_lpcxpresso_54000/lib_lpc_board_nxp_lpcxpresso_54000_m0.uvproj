# Keil uVision project lib_lpc_board_nxp_lpcxpresso_54000_m0.uvproj, settings and files
target nxp_lpcespresso_lpc540xx (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(10000000) ELITTLE
  output: board_nxp_lpcxpresso_lpc540xx_m0 (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\lpc_chip\chip_common;..\..\..\lpc_board\board_common;.\;..\..\..\..\CMSIS\CMSIS\Include;..\..\..\lpc_chip\chip_540xx;..\..\..\lpc_chip\chip_540xx\config
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x20000
  group bsp
    ./: board.c board_sysinit.c
