# Keil uVision project lib_lpc_board_nxp_lpcxpresso_54000.uvproj, settings and files
target nxp_lpcxpresso_lpc540xx (ARM-ADS)
  device: ARMCM4 ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: board_nxp_lpcxpresso_lpc540xx (library)
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\lpc_chip\chip_common;..\..\..\lpc_board\board_common;..\..\..\..\CMSIS\CMSIS\Include;..\..\..\lpc_chip\chip_540xx;..\..\..\lpc_chip\chip_540xx\config;.\;..\..\..\lpc_chip\chip_540xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ./: board.c board_sysinit.c
