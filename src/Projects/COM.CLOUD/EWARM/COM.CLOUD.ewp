# IAR project COM.CLOUD.ewp, settings and files
configuration EMW3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\EMW3162; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.CLOUD.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICO_EVB_1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\MICO_EVB_1; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc; ..\..\..\External\FatFs\src\drivers; ..\..\..\External\FatFs\src; ..\..\..\Platform\Common\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\Platform\Common\Drivers\STM32_USB_Host_Library\Core\Inc
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: ..\..\..\Platform\MICO_EVB_1\micoLinkerForIAR.icf
configuration Nucleo_411RE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\micoLinkerForIAR.icf
configuration EMW3165 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\EMW3165; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: as above
configuration EMW3161 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\EMW3161; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3161\micoLinkerForIAR.icf
configuration FRDM_K64F_SPP (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\BoardConfig\FRDM_K64; ..\..\..\Platform\BoardConfig\FRDM_K64\hal; ..\..\..\Platform\BoardConfig\FRDM_K64\startup; ..\..\..\Platform\BoardConfig\FRDM_K64\driver; ..\..\..\Platform\BoardConfig\FRDM_K64\device; ..\..\..\Platform\BoardConfig\FRDM_K64\boards; ..\..\..\Platform\BoardConfig\FRDM_K64\utilities; ..\..\..\Platform\Vendor\Freescale\MK64FxxL12; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Drivers\spi_flash
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: ..\..\..\Platform\BoardConfig\FRDM_K64\K64FN1Mxxx12_flash.icf
configuration LPCXpresso54102 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: DEBUG; IAR; CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\BoardConfig\LPCXpresso54102; ..\..\..\Platform\Vendor\nxp\LPC54xx; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_common; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_540xx; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_540xx\config; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Drivers\spi_flash
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkIcfFile: ..\..\..\Platform\BoardConfig\LPCXpresso54102\LPC540xx_heap.icf
configuration Elink407_V150112 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Demos\COM.CLOUD; ..\..\..\MICO; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Platform\BoardConfig\elink407; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Demos\COM.CLOUD\AppFramework; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Demos\COM.CLOUD; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\include\FogCloud; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Demos\COM.CLOUD\User; ..\..\..\..\..\..\orange\1062\ELinkKIT\MICO\Platform\Elink407_V150112\Drivers\MiCOKit_EXT
  ILINK.IlinkIcfFile: ..\..\..\Platform\Elink407_V150112\micoLinkerForIAR.icf
  group Application/AppFramework
    ../../../Demos/COM.CLOUD/AppFramework/: fogCloud.c fogCloud.h fogcloud_msg_dispatch.c fogcloud_msg_dispatch.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h properties.c properties.h
  group Application/User
    ../../../Demos/COM.CLOUD/User/: user_config.h user_main.c user_properties.c user_properties.h user_uart.c user_uart.h
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/FogCloud
    ../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group include/MicoDriver
    ../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
  group Library/FogCloud
    ../../../Library/FogCloud/: FogCloud_cm4_debug.a
  group MICO
    ../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICOForceOTA.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c wifi_config.c wifi_config.h
    ../../../MICO/tftp/: tftpc.o
  group MICO/EasyLink
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WAC
    ../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../MICO/WPS/: WPS.c
  group Platform/boardConfig/elink407
    ../../../Platform/BoardConfig/elink407/: platform.c platform.h
    ../../../Platform/Elink407_V150112/: platform_common_config.h
  group Platform/boardConfig/FRDM_K64F
    ../../../Platform/BoardConfig/FRDM_K64/hal/: edma.c fsl_edma_common.c fsl_edma_driver.c fsl_uart_common.c fsl_uart_driver.c fsl_uart_edma_driver.c fsl_uart_hal.c fsl_uart_irq.c
    ../../../Platform/BoardConfig/FRDM_K64/utilities/: fsl_debug_console.c mem_tools.c
    ../../../Platform/BoardConfig/FRDM_K64/irq_handler/: fsl_dspi_irq.c fsl_edma_irq.c
    ../../../Platform/BoardConfig/FRDM_K64/boards/: gpio_pins.c hardware_init.c pin_mux.c
    ../../../Platform/BoardConfig/FRDM_K64/: platform.c
    ../../../Platform/BoardConfig/FRDM_K64/startup/: startup.c startup_MK64F12.s system_MK64F12.c
  group Platform/boardConfig/LPCXpresso54102
    ../../../Platform/BoardConfig/LPCXpresso54102/: iar_startup_lpc540xx.s pinmapping.c platform.c spi_flash_api.c
  group Platform/common/Cortex-M3
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M3/STM32F2xx
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c gpio_irq.h MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c usbh_conf.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: startup_stm32f2xx_IAR.s stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_HAL_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/common/Cortex-M4
    ../../../Platform/Common/Cortex-M4/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M4/STM32F4xx
    ../../../Platform/Common/Cortex-M4/STM32F4xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f4xx_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/: startup_stm32f411xe_IAR.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/common/Drivers
    ../../../Platform/Common/Drivers/: MicoDriverMFiAuth.a
  group Platform/common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: EMW3165.c MICO_EVB_1.c Nucleo_411RE.c spi_flash.c
  group Platform/common/Drivers/STM32_USBH_Library/Class/MSC
    ../../../Platform/Common/Drivers/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Platform/common/Drivers/STM32_USBH_Library/Core
    ../../../Platform/Common/Drivers/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Platform/common/IAR
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/Elink407_V150112/Drivers/Kit_EXT
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Elink407_V150112/Drivers/Kit_EXT/sensors
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c AsciiLib.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c dc_motor.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c DHT11.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c infrared_reflective.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/key/: keys.c keys.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/light/: light_sensor.c light_sensor.h
    ../../../Platform/Elink407_V150112/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Elink407_V150112/Drivers/MFiAuth
    ../../../Platform/Elink407_V150112/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/EMW3161
    ../../../Platform/EMW3161/: platform.c platform.h platform_common_config.h
  group Platform/EMW3162
    ../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Platform/EMW3165
    ../../../Platform/EMW3165/: platform.c platform.h platform_common_config.h
  group Platform/MICO_EVB_1
    ../../../Platform/MICO_EVB_1/: platform.c platform.h platform_common_config.h
  group Platform/Nucleo_411RE
    ../../../Platform/Nucleo_411RE/: platform.c platform.h platform_common_config.h
  group Platform/vendor/Freescale/MK64FNxxL12
    ../../../Platform/vendor/Freescale/MK64FxxL12/: flash_kinetis.c flash_kinetisRamFunc.c fsl_rtc_irq.c gpio_irq.c k64_gpio.c k64_spi.c ksdk_freertos_lib.a ksdk_platform.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c wwd_bus.c
  group Platform/vendor/Freescale/MK64FNxxL12/EMW1062
    ../../../Platform/vendor/Freescale/MK64FxxL12/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/vendor/NXP/LPC54xx
    ../../../Platform/vendor/nxp/LPC54xx/NXP_drivers/: board_nxp_lpcxpresso_54000.a chip_540xx_lib.a
    ../../../Platform/vendor/nxp/LPC54xx/: gpio_irq.c hardfault.c lpc1800_freertos.c lpc_mico.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c nxp_platform.c platform_api.c rtc.c
  group Platform/vendor/NXP/LPC54xx/EMW1062
    ../../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/SDIO/: wlan_bus.c
    ../../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
